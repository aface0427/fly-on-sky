# Keil uVision project ANO_LX_MSP432.uvprojx, settings and files
target Ano_LX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Ano_LX_MSP432
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__
  c include: ..\FcSrc;..\DriversMcu\MSP432P401\Libraries\Include;..\DriversMcu\MSP432P401;..\DriversMcu\MSP432P401\Libraries;..\DriversMcu\MSP432P401\Drivers;..\DriversBsp
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group FcSrc
    ../FcSrc/: main.c SysConfig.h Ano_Scheduler.c Ano_Scheduler.h ANO_LX.c ANO_LX.h User_Task.c User_Task.h LX_FC_Fun.c LX_FC_Fun.h LX_FC_State.c LX_FC_State.h LX_FC_EXT_Sensor.c LX_FC_EXT_Sensor.h ANO_DT_LX.c ANO_DT_LX.h
  group DriversBsp
    ../DriversBsp/: Drv_BSP.c Drv_BSP.h Ano_Math.c Ano_Math.h Drv_AnoOf.c Drv_AnoOf.h Drv_UbloxGPS.c Drv_UbloxGPS.h
  group DriversMcu
    ../DriversMcu/MSP432P401/: McuConfig.h
    ../DriversMcu/MSP432P401/Drivers/: Drv_Sys.c Drv_Sys.h Drv_Timer.c Drv_Timer.h Drv_Uart.c Drv_Uart.h Drv_RcIn.c Drv_RcIn.h Drv_PwmOut.c Drv_PwmOut.h Drv_Adc.c Drv_Adc.h Drv_Gpio.c Drv_Gpio.h Drv_Led.c Drv_Led.h Drv_Paramter.c Drv_Paramter.h
  group LibrariesMcu
    ../DriversMcu/MSP432P401/Libraries/: msp432p4xx_driverlib.lib startup_msp432p401r_uvision.s system_msp432p401r.c
